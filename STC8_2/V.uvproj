# Keil uVision project V.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: V +hex
  c flags: Optimize=8 SizeSpeed=1
  group SYS
    ./SYS/: uart.c uart.h
  group User
    ./User/: main.c main.h
