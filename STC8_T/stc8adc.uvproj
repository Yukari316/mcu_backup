# Keil uVision project stc8adc.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: stc8adc +hex
  c flags: Optimize=8 SizeSpeed=1
  group sensor
    ./sensor/: LMT70.c LMT70.h
  group sys
    ./sys/: ADC.h uart.h ADC.c uart.c STC8F.H gpio.h gpio.c
  group user
    ./user/: main.c main.h
