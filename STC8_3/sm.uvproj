# Keil uVision project sm.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: sm +hex
  c flags: Optimize=8 SizeSpeed=1
  group User
    ./User/: main.c main.h
  group sys
    ./sys/: uart.c uart.h
